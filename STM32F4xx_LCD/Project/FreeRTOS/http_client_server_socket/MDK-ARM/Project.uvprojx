# Keil uVision project Project.uvprojx, settings and files
target Discover-More (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,USE_STM32F4_BRD,_LLONG_AVAILABLE
  c include: ..\inc;..\src;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\lwip_v1.3.2\port\STM32F4x7;..\..\..\..\Utilities\lwip_v1.3.2\src\include;..\..\..\..\Utilities\lwip_v1.3.2\src\include\ipv4;..\..\..\..\Utilities\lwip_v1.3.2\src\include\lwip;..\..\..\..\Utilities\lwip_v1.3.2\src\include\netif;..\..\..\..\Utilities\lwip_v1.3.2\port\STM32F4x7\FreeRTOS;..\..\..\..\Utilities\FreeRTOSv9.0.0\include;..\..\..\..\Utilities\FreeRTOSv9.0.0\portable\RVDS\ARM_CM4F;..\STM32F4Discovery;..\GUIlib\inc;..\Embedded_GUI_HAL\inc;..\Embedded_GUI_Library\inc;..\MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c system_stm32f4xx.c stm32f4xx_it.c netconf.c stm32f4x7_eth_bsp.c fs.c httpserver-socket.c httpclient-socket.c miscellaneous.c hw_config.c
    ./: flash_memory_driver.c flash_memory_driver.h DisplayNumber.c DisplayNumber.h ADC.c
  group GUI_User
    ../GUIlib/src/: pictures.c uiappuser.c uiframework.c
  group GUI_HAL
    ../Embedded_GUI_HAL/src/: LcdHal.c
  group GUI_Library
    ../Embedded_GUI_Library/src/: cursor.c gl_fonts.c graphicObject.c images.c
  group STM32F4-Discovery
    ../src/: stm32f4xx_uartstdio.c
    ../STM32F4Discovery/: stm32f4_discovery_LCD_SSD1963.c fonts.c stm32f4_discovery_tsc2046.c stm32f4_discovery_user.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_flash.c
  group STM32F4x7_ETH_Driver
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group LWIP
    ../../../../Utilities/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../Utilities/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../../Utilities/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../Utilities/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../../../../Utilities/lwip_v1.3.2/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group FreeRTOS
    ../../../../Utilities/FreeRTOSv9.0.0/: croutine.c list.c queue.c tasks.c
    ../../../../Utilities/FreeRTOSv9.0.0/portable/RVDS/ARM_CM4F/: port.c
    ../../../../Utilities/FreeRTOSv9.0.0/portable/MemMang/: heap_2.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group Readme
    ../: readme.txt
software components: CMSIS:CORE 3.40.0
